# Keil uVision project LABTEMP1.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: LABTEMP1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, TWR_K60D100M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 --library_interface=armcc
  c include: C:/Freescale/KSDK_1.2.0/platform/osa/inc;C:/Freescale/KSDK_1.2.0/platform/utilities/inc;C:/Freescale/KSDK_1.2.0/platform/CMSIS/Include;C:/Freescale/KSDK_1.2.0/platform/devices;C:/Freescale/KSDK_1.2.0/platform/devices/MK60D10/include;C:/Freescale/KSDK_1.2.0/platform/devices/MK60D10/startup;C:/Freescale/KSDK_1.2.0/platform/hal/inc;C:/Freescale/KSDK_1.2.0/platform/drivers/inc;C:/Freescale/KSDK_1.2.0/platform/system/inc;C:/Freescale/KSDK_1.2.0/platform/utilities/inc;C:/Freescale/KSDK_1.2.0/platform/drivers/src/gpio;..\..\..\twrk60d100m;..\..\..\..\platform\utilities\inc;..\..\..\..\platform\utilities\src;..\..\..\..\platform\drivers\inc;..\..\..\..\platform\drivers\src\lptmr;..\..\..\..\platform\hal\inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\..\platform\devices\MK60D10\linker\arm\MK60DN512xxx10_flash.scf
  link misc: C:\Freescale\KSDK_1.2.0\lib\ksdk_platform_lib\mdk\K60D10\debug\libksdk_platform.lib --remove
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h fsl_misc_utilities.h
  group startup
    ../../../../platform/devices/MK60D10/startup/arm/: startup_MK60D10.s
    ../../../../platform/devices/MK60D10/startup/: system_MK60D10.c system_MK60D10.h
    ../../../../platform/devices/: startup.c startup.h fsl_device_registers.h
  group board
    ../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../driver_examples/gpio/: hardware_init.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
  group source
    ./: main.c fsl_lptmr_irq.c asmmain.s
